* Netlist for biasing the pMOS input pair
**************
* Model file *
.lib "../../models/45nm.lib" tt
**************
R1 vdd X_m6diode_s res 19.32516
X_m6diode X_m6diode_s b4 b4 vdd pmos w=135u l=45n
Ibias b4 vss
X_M5a
X_M6a int_1 b5 vdd vdd pmos w=135u l=180n
X_M6_diode b5 b5 vdd vdd pmos w=135u l=180n
